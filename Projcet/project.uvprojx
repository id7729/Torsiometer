# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AC7811QBFE AutoChips
  pack: AutoChips.AC781x_DFP.1.1.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_Sample +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\Projcet;..\User\UartScreen
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c LED.c LED.h Timer.c Timer.h Round_Robin_Sche.c Round_Robin_Sche.h RS485_driver.c RS485_driver_private.h RS485_driver_public.h demo.c demo.h WorkMode.c WorkMode.h WTN6040.c WTN6040.h
  group UartScreen
    ../User/UartScreen/: DMG80480C043_01WTC.c DMG80480C043_01WTC.h VarMalloc.c VarMalloc.h
software components: CMSIS:CORE 5.5.0, Board Support:AC781x Development Kit:Debug Interface 1.0.0, Device:ATC Drivers:ACMP 1.0.0, Device:ATC Drivers:ADC 1.0.0, Device:ATC Drivers:CAN 1.0.0, Device:ATC Drivers:CRC 1.0.0, Device:ATC Drivers:CTU 1.0.0, Device:ATC Drivers:DMA 1.0.0, Device:ATC Drivers:GPIO 1.0.0, Device:ATC Drivers:I2C 1.0.0, Device:ATC Drivers:LIN 1.0.0, Device:ATC Drivers:PWDT 1.0.0, Device:ATC Drivers:PWM 1.0.0, Device:ATC Drivers:RTC 1.0.0, Device:ATC Drivers:SPI 1.0.0, Device:ATC Drivers:TIMER 1.0.0, Device:ATC Drivers:UART 1.0.0, Device:ATC Drivers:Watchdog 1.0.0, Device:ATC Drivers:eFlash 1.0.0, Device:ATC Drivers:sFlash 1.0.0, Device:Startup 1.0.0
